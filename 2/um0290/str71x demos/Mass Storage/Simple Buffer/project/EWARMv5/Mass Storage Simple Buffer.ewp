# IAR project Mass Storage Simple Buffer.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\..\..\..\USBLib\inc; ..\..\..\..\..\FWLib\str71x\inc; ..\..\include\; ..\..\..\common\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: Mass Storage Simple Buffer.out
  ILINK.IlinkIcfFile: STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application files
    ../../../Common/source/: 71x_it.c hw_config.c main.c SCSI_data.c usb_desc.c usb_istr.c usb_pwr.c
    ../../source/: memory.c usb_bot.c usb_endp.c usb_prop.c usb_scsi.c
  group EWARMv5
    ./: 71x_init.s 71x_vect.s
  group FWLib
    ../../../../../FWLib/str71x/src/: 71x_apb.c 71x_eic.c 71x_emi.c 71x_gpio.c 71x_lib.c 71x_pcu.c 71x_rccu.c 71x_xti.c
  group USBLib
    ../../../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
