# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\FWLib\str71x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: Speaker Demo.out
  ILINK.IlinkIcfFile: STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    ./: 71x_init.s 71x_vect.s
  group FWLib
    ../../../../../FWLib/str71x/src/: 71x_apb.c 71x_eic.c 71x_gpio.c 71x_lib.c 71x_pcu.c 71x_rccu.c 71x_xti.c
  group User
    ../../: 71x_it.c main.c
