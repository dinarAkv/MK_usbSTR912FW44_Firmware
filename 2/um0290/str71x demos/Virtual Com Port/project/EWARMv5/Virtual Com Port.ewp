# IAR project Virtual Com Port.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\..\USBLib\inc; ..\..\..\..\FWLib\str71x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: Virtual Com Port.out
  ILINK.IlinkIcfFile: STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application files
    ../../source/: 71x_it.c hw_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARMv5
    ./: 71x_init.s 71x_vect.s
  group FWLib
    ../../../../FWLib/str71x/src/: 71x_apb.c 71x_eic.c 71x_gpio.c 71x_lib.c 71x_pcu.c 71x_rccu.c 71x_uart.c 71x_xti.c
  group USBLib
    ../../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
