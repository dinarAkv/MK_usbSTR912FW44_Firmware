# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR710 ST STR710
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\FWLib\str75x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: Speaker Demo.out
  ILINK.IlinkIcfFile: STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    ./: 75x_init.s 75x_vect.s
  group FWLib
    ../../../../../FWLib/str75x/src/: 75x_eic.c 75x_extit.c 75x_gpio.c 75x_lib.c 75x_mrcc.c
  group User
    ../../: 75x_it.c main.c
