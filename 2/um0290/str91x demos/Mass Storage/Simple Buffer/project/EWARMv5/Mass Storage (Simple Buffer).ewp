# IAR project Mass Storage (Simple Buffer).ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912FA ST STR912FA
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\Common\include; ..\..\..\..\..\USBLib\inc; ..\..\..\..\..\FWLib\str91x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: Mass Storage (Simple Buffer).out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application files
    ../../../Common/source/: 91x_it.c hw_config.c main.c scsi_data.c usb_desc.c usb_istr.c usb_pwr.c usb_rw.c
    ../../source/: memory.c usb_bot.c usb_endp.c usb_prop.c usb_scsi.c
  group EWARMv5
    ./: 91x_init.s 91x_vect.s
  group FWLib
    ../../../../../FWLib/str91x/src/: 91x_ahbapb.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_rtc.c 91x_scu.c 91x_vic.c
  group USBLib
    ../../../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
