# IAR project project.ewp, settings and files
configuration user application (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912FA ST STR912FA
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\FWLib\str91x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARMv5
    ./: 91x_init.s 91x_vect.s
  group FWLib
    ../../../../../FWLib/str91x/src/: 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_rtc.c 91x_scu.c 91x_vic.c
  group User
    ../../: 91x_it.c main.c
