# IAR project Device Firmware Upgrade.ewp, settings and files
configuration STR9_512KB_256KB (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912FA ST STR912FA
  ICCARM.CCDefines: Flash_512KB_256KB
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\USBLib\inc; ..\..\..\..\FWLib\str91x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: Flash_512KB_256KB
  ILINK.IlinkOutputFile: Device Firmware Upgrade.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STR9_2MB_1MB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STR912FAx47 ST STR912FAx47
  ICCARM.CCDefines: Flash_2MB_1MB
  AARM.ADefines: Flash_2MB_1MB
  group Application files
    ../../source/: 91x_it.c hw_config.c main.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARMv5
    ./: 91x_init.s 91x_vect.s
  group FWLib
    ../../../../FWLib/str91x/src/: 91x_ahbapb.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_ssp.c 91x_vic.c
  group USBLib
    ../../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
