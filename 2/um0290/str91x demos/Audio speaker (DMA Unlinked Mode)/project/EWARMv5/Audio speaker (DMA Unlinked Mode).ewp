# IAR project Audio speaker (DMA Unlinked Mode).ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912FA ST STR912FA
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\USBLib\inc; ..\..\..\..\FWLib\str91x\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: Audio speaker (DMA Linked Mode).out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application files
    ../../source/: 91x_it.c hw_config.c main.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARMv5
    ./: 91x_init.s 91x_vect.s
  group FWLib
    ../../../../FWLib/str91x/src/: 91x_ahbapb.c 91x_dma.c 91x_fmi.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
  group USBLib
    ../../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
