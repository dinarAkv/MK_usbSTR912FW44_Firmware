# IAR project project.ewp, settings and files
configuration FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STR912FA ST STR912FA
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: STR91x_RAM.icf
  group (top)
    ../: 91x_it.c main.c
  group library
    ../../library/src/: 91x_adc.c 91x_ahbapb.c 91x_can.c 91x_dma.c 91x_emi.c 91x_fmi.c 91x_gpio.c 91x_i2c.c 91x_lib.c 91x_mc.c 91x_rtc.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c 91x_wiu.c
  group startup
    ./: 91x_init.s 91x_vect.s
